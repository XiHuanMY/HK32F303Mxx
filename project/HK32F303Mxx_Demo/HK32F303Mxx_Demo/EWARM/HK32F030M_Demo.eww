<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HK32F030M_Demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
